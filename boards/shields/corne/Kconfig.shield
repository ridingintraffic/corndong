## boards/shields/corne/Kconfig.shield
```kconfig
config SHIELD_CORNE_DONGLE_XIAO
    def_bool $(shields_list_contains,corne_dongle_xiao)
```
